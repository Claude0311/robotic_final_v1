Commit message: test1 - move with segments

File: urdf/snake.urdf (robot description, URDF)
Before this commit: robot snakebot, 22 links, 21 joints
Joints:
- joint dummy_joint: origin (none) -> xyz=0 0 0 rpy=0 0 0
